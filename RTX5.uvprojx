# Keil uVision project RTX5.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTX5
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER
  c include: .\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./src/: main.c MV_32_Usart.c Laser.c
  group Peripheral
    ./src/: LED.c GPIO_EXTI.c Timer.c
  group Driver
    ./src/: Usart.c TTP229.c steer.c Beep_LED.c OLED_SPI.c OLED_SHOW.c Step.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX5 5.5.1, CMSIS:RTOS2:Keil RTX5 5.5.1, CMSIS Driver:SPI 2.12, CMSIS Driver:USART 2.12, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:EXTI 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:SPI 1.7.6, Device:STM32Cube HAL:TIM 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:Startup 2.6.3
